Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 37f0d998-164f-4c6f-b5fb-4b613e20ea5f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: N2BL-02.ifc
Time: 2025-10-19T13:07:20+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: N2BL-02_R23:N2BL-02_R23, N2BL-02_R23:N2BL-02_R23:13705
In: Livello 1
Type - Material: <Unnamed>, Metal, wood
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: N2BL-02_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza lama (cm): 71; altezza tot (cm): 71; ASI: 0,8; CAD layer: n.a.; certificato art 14 comma 22: TOCUSTOMIZE; certificato CE: TOCUSTOMIZE; certificato di corretta posa: TOCUSTOMIZE; Classe: N2; classe intrusione del veicolo: n.a.; classe larghezza di lavoro: W5; cordolo: n.a.; Costo: 133; deflessione dinamica (m): 1,5; Descrizione: (colore); documentazione integrativa (url): TOCUSTOMIZE; DOP: TOCUSTOMIZE; DSM: RiderPro-MRS-04; EPD: sì; GWP totale cradle to gate: 13,10 kgCO2eq/m; infissione (m): 1,085; interasse (m): 4; intrusione del veicolo (m): n.a.; larghezza di lavoro (m): 1,7; larghezza max (cm): 34; lavorazione aggiuntiva: TOCUSTOMIZE; Legno CAM Strade: CoC PEFC; livello di severità: A; lunghezza minima (m): 92; manuale di installazione: TOCUSTOMIZE; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: N2BL-02; N° Certificato CE: CPR/0491/4425; Nome del tipo: N2BL-02_R23; Norma di riferimento: EN 1317-2 e EN1317-5; Prezzo di Capitolato: 133; Prodotto: Barriera di sicurezza stradale; Produttore: Margaritelli Road Safety; progressiva finale: TOCUSTOMIZE; progressiva iniziale: TOCUSTOMIZE; resoconti di prova: TOCUSTOMIZE; supporto: rilevato; testata su arginello: no; Tipologia: N2 Bordo Laterale; Unità di Misura: m; URL: https://margaritelli-rs.com/it/products/n2bl-02/; URL (certificati CE, DOP, manuali, schede tecniche, schemi): https://margaritelli-rs.com/it/products/n2bl-02/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: N2BL-02_R23
Pset_RailingCommon - Reference: N2BL-02_R23; IsExternal: no
Altro - Basement: yes; Bordo_Dx: yes; Bordo_SX: yes; Famiglia: N2BL-02_R23; Famiglia e tipo: N2BL-02_R23: N2BL-02_R23; ID tipo: 13689; Tipo: N2BL-02_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 14.3416 m2; Volume: 0.359285 m3
